# Keil uVision project liuchuanjia.uvprojx, settings and files
target liuchuanjia (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: liuchuanjia +hex
  c flags: Optim=1 uC99=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\FWlib\inc;..\USER;..\CMSIS;..\USER\main;..\Serivce\include;..\Serivce\library;..\lock_driver;..\Serivce;..\USER\STM32_Cryptographic\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startcode
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group lib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c misc.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_flash.c
  group user
    ../USER/main/: main.c
    ../USER/stm32f10x_it/: stm32f10x_it.c
    ../USER/STM32_ID/: chipid.c
    ../USER/Tim/: Time2_App.c
    ../USER/delay/: delay.c
    ../USER/key/: key.c
    ../USER/Usart_string/: Usart_string.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group usart
    ../USER/usart1/: usart1.c
  group Administer
    ../USER/Administrator/: Admin.c
  group Commen_user
    ../USER/Commen_User/: Com_user.c
  group AT24C128
    ../USER/AT24C128/: 24cxx.c myiic.c sys.c
  group W25Q32BV
    ../USER/W25Q32BV/: spi_flash.c
  group Tem_User
    ../USER/Tem_User/: Tem_User.c
  group Door_Control
    ../USER/Door_Control/: Door_Control.c
  group Json_service
    ../USER/JSON_Service/: json_infer.c cJSON.c
  group STM32_Cryptographic
    ../USER/STM32_Cryptographic/: arc4.c rsa_think.c str_hex.c
    ../USER/STM32_Cryptographic/Lib/: STM32CryptographicV3.0.0_CM3_KEIL_otslsm1elfspf.lib STM32CryptographicV3.0.0_CM3_KEIL_slsm1elfspf.lib
